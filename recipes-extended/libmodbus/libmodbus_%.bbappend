# Append the specific configuration flags to the autotools configure step
EXTRA_OECONF:append = " --with-pic --enable-static --enable-shared=no"
