SUMMARY = "Python core runtime for LSMY system"
DESCRIPTION = "Python 3 interpreter and basic Python package management"
LICENSE = "MIT"

inherit packagegroup

# ====== PYTHON CORE ======
# - Python interpreter
# - Python package manager (pip)
#RDEPENDS:${PN} = "\
#    python3 \
#    python3-pip \
#"
