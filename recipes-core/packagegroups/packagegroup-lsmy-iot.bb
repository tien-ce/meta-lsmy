SUMMARY = "IoT communication stack for LSMY"
DESCRIPTION = "Network communication and IoT-oriented application development"
LICENSE = "MIT"

inherit packagegroup

# ====== PYTHON NETWORK & IOT ======
# - HTTP client
# - MQTT client
# - WebSocket client
#RDEPENDS:${PN} = "\
#    python3-requests \
#    python3-paho-mqtt \
#    python3-websocket-client \
#"
