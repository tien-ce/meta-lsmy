PACKAGECONFIG:append = " gstreamer v4l gtk"
#PACKAGECONFIG:remove = "gphoto2 samples"